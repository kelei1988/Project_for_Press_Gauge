<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\New_Press_Gauge_SV1.1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


